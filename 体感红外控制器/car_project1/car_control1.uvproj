# Keil uVision project car_control1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: car_control1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc
  group Source Group 1
    ./: STARTUP.A51 main.c ADXL345_Func.c ADXL345.c
    ../: STCBSP_V3.6.LIB
