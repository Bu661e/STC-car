# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group comu
    ./source/: ir_re.c btooth.c
  group comp
    ./source/: buzzer.c vibration.c btn.c dis.c motor.c light.c
  group rela
    ./source/: main.c
    ./: STCBSP_V3.6.LIB STARTUP.A51
